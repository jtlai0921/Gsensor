# Keil uVision project Gsenser.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NANO130KE3BN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.0.7
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: Gsenser
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: main.c RFoutput.c I2C.c
software components: CMSIS:CORE 5.1.1, Device:Driver:CLK 3.01.000, Device:Driver:SPI 3.01.000, Device:Driver:SYS 3.01.000, Device:Driver:UART 3.01.000, Device:Startup 3.01.000
